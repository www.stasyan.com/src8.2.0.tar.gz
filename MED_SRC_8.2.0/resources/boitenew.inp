GRID  UNSTructured         324 elements
CONNectivity  'boitenew.cnc'
COORdinate VERTices X Y 'boitenew.xyz'
LOCAte LIST ID=re10                
    163 ,     164 ,     165 ,     166 ,     167 ,     168 ,     169 ,     170 ,     171 ,     172
    173 ,     174 ,     175 ,     176 ,     177 ,     178 ,     179 ,     180 ,     181 ,     182
    183 ,     184 ,     185 ,     186 ,     187 ,     188 ,     189 ,     190 ,     191 ,     192
    193 ,     194 ,     195 ,     196 ,     197 ,     198 ,     199 ,     200 ,     201 ,     202
    203 ,     204 ,     205 ,     206 ,     207 ,     208 ,     209 ,     210 ,     211 ,     212
    213 ,     214 ,     215 ,     216 ,     217 ,     218 ,     219 ,     220 ,     221 ,     222
    223 ,     224 ,     225 ,     226 ,     227 ,     228 ,     229 ,     230 ,     231 ,     232
    233 ,     234 ,     235 ,     236 ,     237 ,     238 ,     239 ,     240 ,     241 ,     242
    243 ,     244 ,     245 ,     246 ,     247 ,     248 ,     249 ,     250 ,     251 ,     252
    253 ,     254 ,     255 ,     256 ,     257 ,     258 ,     259 ,     260 ,     261 ,     262
    263 ,     264 ,     265 ,     266 ,     267 ,     268 ,     269 ,     270 ,     271 ,     272
    273 ,     274 ,     275 ,     276 ,     277 ,     278 ,     279 ,     280 ,     281 ,     282
    283 ,     284 ,     285 ,     286 ,     287 ,     288 ,     289 ,     290 ,     291 ,     292
    293 ,     294 ,     295 ,     296 ,     297 ,     298 ,     299 ,     300 ,     301 ,     302
    303 ,     304 ,     305 ,     306 ,     307 ,     308 ,     309 ,     310 ,     311 ,     312
    313 ,     314 ,     315 ,     316 ,     317 ,     318 ,     319 ,     320 ,     321 ,     322
    323 ,     324 , 
LOCAte LIST ID=re11                
      1 ,       2 ,       3 ,       4 ,       5 ,       6 ,       7 ,       8 ,       9 ,      10
     11 ,      12 ,      13 ,      14 ,      15 ,      16 ,      17 ,      18 ,      19 ,      20
     21 ,      22 ,      23 ,      24 ,      25 ,      26 ,      27 ,      28 ,      29 ,      30
     31 ,      32 ,      33 ,      34 ,      35 ,      36 ,      37 ,      38 ,      39 ,      40
     41 ,      42 ,      43 ,      44 ,      45 ,      46 ,      47 ,      48 ,      49 ,      50
     51 ,      52 ,      53 ,      54 ,      55 ,      56 ,      57 ,      58 ,      59 ,      60
     61 ,      62 ,      63 ,      64 ,      65 ,      66 ,      67 ,      68 ,      69 ,      70
     71 ,      72 ,      73 ,      74 ,      75 ,      76 ,      77 ,      78 ,      79 ,      80
     81 ,      82 ,      83 ,      84 ,      85 ,      86 ,      87 ,      88 ,      89 ,      90
     91 ,      92 ,      93 ,      94 ,      95 ,      96 ,      97 ,      98 ,      99 ,     100
    101 ,     102 ,     103 ,     104 ,     105 ,     106 ,     107 ,     108 ,     109 ,     110
    111 ,     112 ,     113 ,     114 ,     115 ,     116 ,     117 ,     118 ,     119 ,     120
    121 ,     122 ,     123 ,     124 ,     125 ,     126 ,     127 ,     128 ,     129 ,     130
    131 ,     132 ,     133 ,     134 ,     135 ,     136 ,     137 ,     138 ,     139 ,     140
    141 ,     142 ,     143 ,     144 ,     145 ,     146 ,     147 ,     148 ,     149 ,     150
    151 ,     152 ,     153 ,     154 ,     155 ,     156 ,     157 ,     158 ,     159 ,     160
    161 ,     162 , 
LOCAte PAIR ID=ref1                
/ FRONTIERE REF :      1
      1 ,       3 ;       2 ,       3 ;       3 ,       3 ;       4 ,       3 ;       5 ,       3
      6 ,       3 ;       7 ,       3 ;       8 ,       3 ;       9 ,       3 ;     163 ,       3
    164 ,       3 ;     165 ,       3 ;     166 ,       3 ;     167 ,       3 ;     168 ,       3
    169 ,       3 ;     170 ,       3 ;     171 ,       3 ; 
LOCAte PAIR ID=ref2                
/ REF =      2  MATERIAU =     11
      9 ,       2 ;      18 ,       2 ;      27 ,       2 ;      36 ,       2 ;      45 ,       2
     54 ,       2 ;      63 ,       2 ;      72 ,       2 ;      81 ,       2 ;      90 ,       2
     99 ,       2 ;     108 ,       2 ;     117 ,       2 ;     126 ,       2 ;     135 ,       2
    144 ,       2 ;     153 ,       2 ;     162 ,       2 ; 

LOCAte PAIR ID=ref3                
/ FRONTIERE REF :      3
    154 ,       4 ;     155 ,       4 ;     156 ,       4 ;     157 ,       4 ;     158 ,       4
    159 ,       4 ;     160 ,       4 ;     161 ,       4 ;     162 ,       4 ;     316 ,       4
    317 ,       4 ;     318 ,       4 ;     319 ,       4 ;     320 ,       4 ;     321 ,       4
    322 ,       4 ;     323 ,       4 ;     324 ,       4 ; 
LOCAte PAIR ID=ref4                
/ REF =      4  MATERIAU =     10
    163 ,       1 ;     172 ,       1 ;     181 ,       1 ;     190 ,       1 ;     199 ,       1
    208 ,       1 ;     217 ,       1 ;     226 ,       1 ;     235 ,       1 ;     244 ,       1
    253 ,       1 ;     262 ,       1 ;     271 ,       1 ;     280 ,       1 ;     289 ,       1
    298 ,       1 ;     307 ,       1 ;     316 ,       1 ; 

LOCAte PAIR ID=ref5                
/ REF =      5  MATERIAU =     10
    171 ,       2 ;     180 ,       2 ;     189 ,       2 ;     198 ,       2 ;     207 ,       2
    216 ,       2 ;     225 ,       2 ;     234 ,       2 ;     243 ,       2 ;     252 ,       2
    261 ,       2 ;     270 ,       2 ;     279 ,       2 ;     288 ,       2 ;     297 ,       2
    306 ,       2 ;     315 ,       2 ;     324 ,       2 ; 

